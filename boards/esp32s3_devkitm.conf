## boards/esp32s3_devkitm.conf
```kconfig
CONFIG_LV_COLOR_16_SWAP=y
CONFIG_MAIN_STACK_SIZE=5000
CONFIG_SENSOR=y
CONFIG_INPUT=y
CONFIG_GPIO=y
CONFIG_GPIO_SHELL=y
```
